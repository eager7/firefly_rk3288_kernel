## drivers/video/rockchip/vga/Kconfig
```kconfig
config  FIREFLY_VGA
        bool "Firefly VGA Out/In support"
        help
           Support Firefly VGA in if you say y here
```
